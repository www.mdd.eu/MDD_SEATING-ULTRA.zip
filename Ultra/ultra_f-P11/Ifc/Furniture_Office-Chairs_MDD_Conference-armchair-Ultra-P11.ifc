Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Furniture_Office-Chairs_MDD_Conference-armchair-Ultra-P11.ifc
Time: 2020-03-04T09:33:17
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFurnishingElement: Conference armchair Ultra P11
ePset_BIMobjectScript - Base: Base P1; LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): Conference armchair Ultra P11; SKU (BO_prodsku): ultra_f-P11; ManufacturName (BO_Manufac): MDD; BrandUrl (BO_brandurl): http://www.mdd.eu; ProductFamily (BO_prodfam): Soft Seating; ProductGroup (BO_prodgroup): Ultra; ManufacturCountry (BO_mancont): Poland; DesignCountry (BO_designcont): Poland; EditionNumber (BO_edinum): 1; Width (BO_width): 600; Height (BO_height): 850; Depth (BO_depth): 600; Weight (BO_weight): 18; QR (BO_boqrurl): http://bimobject.com/mdd/product/ultra_f-P11; ProductDataUrl (BO_prodaturl): bimobject.com/mdd/product/ultra_f-P11; ProductUrl (BO_producturl): https://mdd.eu/en/seating/ultra/; TechnicalDescription (BO_techcert): https://mdd.eu/wp-content/uploads/ultra_en-4.pdf; MaterialMain (BO_mainmat): Fabric; MaterialSecondary (BO_secmat): Metal; BimObjectMainCategory (BO_bomaincat): Furniture; BimObjectMainCategoryCode (BO_bomaincat_code): furniture; BimObjectCategory (BO_bocat): Office Chairs; BimObjectCategoryCode (BO_bocat_code): furniture-office-chairs; IfcClassification (BO_ifcclas): Furniture; UnspscCode (BO_unspsc): 56; Uniclass14Code (BO_uniclass_1_4_code): L8222; Uniclass14Description (BO_uniclass_1_4_desc): Chairs; Uniclass20Code (BO_uniclass_2_0_code): PR-31-12; Uniclass20Description (BO_uniclass_2_0_desc): Chairs, Seats And Bench Seating; Uniclass2015Code (BO_uniclass2015_code): Pr_40_50_12; Uniclass2015Description (BO_uniclass2015_desc): Chairs, seats and benches; NBSReference (BO_nbs_ref): 31-12; NBSReferenceDescription (BO_nbs_desc): Chairs, Seats And Bench Seating; MasterFormat2014Code (BO_masterformat2014_code): 12 52 13; MasterFormat2014Description (BO_masterformat2014_name): Chairs; UniFormat2Code (BO_uniformat2_code): E2020; UniFormat2Description (BO_uniformat2_name): Movable Furnishings; RegionEurope (BO_europe): AD, AL, AT, AX, BA, BE, BG, BY, CH, CY, CZ, DE, DK, EE, ES, FI, FO, FR, GB, GG, GI, GR, HR, HU, IE, IM, IS, IT, JE, LI, LT, LU, LV, MC, MD, ME, MK, MT, NL, NO, PL, PT, RO, RS, RU, SE, SI, SJ, SK, SM, UA, VA; RegionNorthAmerica (BO_northamerica): AG, AI, AW, BB, BL, BM, BQ, BS, BZ, CA, CR, CU, CW, DM, DO, GD, GL, GP, GT, HN, HT, JM, KN, KY, LC, MF, MQ, MS, MX, NI, PA, PM, PR, SV, SX, TC, TT, US, VC, VG, VI; RegionSouthAmerica (BO_southamerica): AR, BO, BR, CL, CO, EC, FK, GF, GY, PE, PY, SR, UY, VE; RegionMiddleEast (BO_middleeast): AE, AF, BH, EG, IL, IQ, IR, JO, KW, LB, OM, PS, QA, SA, SY, TR, YE; RegionAsia (BO_asia): AM, AZ, BD, BN, BT, CC, CN, CX, GE, HK, ID, IN, IO, JP, KG, KH, KR, KZ, LA, LK, MM, MN, MO, MV, MY, NP, PH, PK, SG, TH, TJ, TM, TW, UZ, VN; RegionOceania (BO_oceania): AS, AU, CK, FJ, FM, GU, KI, MH, MP, NC, NF, NR, NU, NZ, PF, PG, PN, PW, SB, TK, TL, TO, TV, UM, WF, WS, VU; RegionAfrica (BO_africa): AO, BF, BI, BJ, BW, CD, CF, CG, CI, CM, CV, DJ, DZ, EH, ER, ET, GA, GH, GM, GN, GQ, GW, KE, KM, LR, LS, LY, MA, MG, ML, MR, MU, MW, MZ, NA, NE, NG, RE, RW, SC, SD, SH, SL, SN, SO, SS, ST, SZ, TD, TG, TN, TZ, UG, YT, ZA, ZM, ZW
